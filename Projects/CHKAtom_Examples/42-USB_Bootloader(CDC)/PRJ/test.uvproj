# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: test +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\SRC\USER;..\SRC\SYSTEM\DELAY;..\SRC\SYSTEM\GPIO;..\SRC\SYSTEM\SYS;..\SRC\SYSTEM\UART;..\SRC\SYSTEM\WDOG;..\SRC\HARDWARE;..\SRC\HARDWARE\LED;..\SRC\USB;..\SRC\BOOTLOADER;..\SRC\HARDWARE\KEY
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_MK60D10.s
  group USER
    ../SRC/USER/: main.c
  group SYSTEM
    ../SRC/SYSTEM/DELAY/: delay.c
    ../SRC/SYSTEM/GPIO/: gpio.c
    ../SRC/SYSTEM/SYS/: sys.c
    ../SRC/SYSTEM/UART/: uart.c
    ../SRC/SYSTEM/WDOG/: wdog.c
  group HARDWARE
    ../SRC/HARDWARE/LED/: led.c
    ../SRC/HARDWARE/KEY/: key.c
  group BOOTLOADER
    ../SRC/BOOTLOADER/: bootloader.c bootloader_util.c flash_operate.c message_manage.c
  group USB
    ../SRC/USB/: USB.c usb_cdc.c usb_hid.c
