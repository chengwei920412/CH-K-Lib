# IAR project Templete.ewp, settings and files
configuration Example_CHK60EVB (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN256xxx10 Freescale MK60DN256xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\drivers\inc; ..\..\..\..\Libraries\devices\ads7843; ..\..\..\..\Libraries\devices\led; ..\..\..\..\Libraries\devices\lcd; ..\..\..\..\Libraries\devices\kbi; ..\..\..\..\Libraries\devices\nrf2401; ..\..\..\..\Libraries\devices\spiflash; ..\..\..\..\Libraries\utilities\chgui; ..\..\..\..\Libraries\utilities\minishell; ..\..\..\..\Libraries\znfat; ..\src; ..\src\uIP-1.0\uip; ..\src\uIP-App; ..\src\uIP-Port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Templete.out
  ILINK.IlinkIcfFile: toolchain\256KB_PFlash_64KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group devices
    ../../../../Libraries/devices/ads7843/: ads7843.c
    ../../../../Libraries/devices/kbi/: kbi.c kbi_chk60evb.c
    ../../../../Libraries/devices/lcd/: lcd_chk60evb.c
    ../../../../Libraries/devices/led/: led.c led_chk60evb.c
    ../../../../Libraries/devices/nrf2401/: nrf2401.c
    ../../../../Libraries/devices/spiflash/: spiflash.c
  group drivers
    ../../../../Libraries/drivers/src/: adc.c can.c dac.c delay.c dma.c enet.c flash.c ftm.c gpio.c i2c.c lptm.c pdb.c pit.c rtc.c sd.c spi.c sys.c tsi.c uart.c wdog.c
  group startup
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: crt0.s startup.c startup_MK60DZ10.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK60DZ10.c
  group uip
    ../src/uIP-1.0/uip/: psock.c timer.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group uip-app
    ../src/uIP-App/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c tcp_client_demo.c tcp_server_demo.c tcp_web_demo.c uip_demo.c
  group uip-port
    ../src/uIP-Port/: clock-arch.c tapdev.c uip-conf.h
  group user
    ../src/: isr.c isr.h main.c
  group utilities
    ../../../../Libraries/utilities/chgui/: chgui.c chgui_bmp.c chgui_char.c chgui_touch.c
    ../../../../Libraries/utilities/minishell/: minishell.c
  group znfat
    ../../../../Libraries/znfat/: deviceio.c znFAT.c
