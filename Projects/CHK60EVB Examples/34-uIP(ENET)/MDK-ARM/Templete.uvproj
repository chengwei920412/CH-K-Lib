# Keil uVision project Templete.uvproj, settings and files
target Templete (ARM-ADS)
  device: MK60DN256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x4FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: Templete +hex
  c flags: Optim=1
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\inc;..\..\..\..\Libraries\devices\led;..\..\..\..\Libraries\devices\kbi;..\..\..\..\Libraries\devices\lcd;..\..\..\..\Libraries\utilities\chgui;..\..\..\..\Libraries\devices\spiflash;..\..\..\..\Libraries\devices\ads7843;..\..\..\..\Libraries\utilities\minishell;..\src\uIP-1.0\uip;..\src\uIP-App;..\src\uIP-Port
  memory RVCT4: ROM 0x0 size 0x50000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60DZ10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60DZ10.s
  group utilities
    ../../../../Libraries/utilities/chgui/: chgui.c chgui_char.c chgui_bmp.c chgui_touch.c
    ../../../../Libraries/utilities/minishell/: minishell.c
  group devices
    ../../../../Libraries/devices/led/: led.c led_chk60evb.c
    ../../../../Libraries/devices/kbi/: kbi.c kbi_chk60evb.c
    ../../../../Libraries/devices/lcd/: lcd_chk60evb.c
    ../../../../Libraries/devices/spiflash/: spiflash.c
    ../../../../Libraries/devices/ads7843/: ads7843.c
  group drivers
    ../../../../Libraries/drivers/src/: sys.c uart.c gpio.c adc.c can.c dac.c delay.c dma.c enet.c flash.c ftm.c i2c.c lptm.c pdb.c pit.c rtc.c sd.c spi.c tsi.c wdog.c
  group user
    ../src/: main.c isr.c
  group uIP-1.0
    ../src/uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP-Port
    ../src/uIP-Port/: clock-arch.c tapdev.c uip-conf.h
  group uIP-App
    ../src/uIP-App/: httpd.c httpd-cgi.c httpd-fs.c http-strings.c tcp_client_demo.c tcp_server_demo.c tcp_web_demo.c uip_demo.c
